# Keil uVision project MyFreeRTOS.uvproj, settings and files
target RTOSDemo_ARM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS
  c include: .\include;.\FreeRTOS\Include;.\application
  asm include: .\FreeRTOS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Application
    ./application/: main.c FreeRTOSConfig.h Startup.s
  group FreeRTOS
    ./FreeRTOS/Source/: heap_1.c list.c port.c portASM.s queue.c tasks.c
  group Drivers
    ./drivers/gpio/: GPIO_cfg.c GPIO.c
    ./drivers/serial/: serial.c serialISR.s
target RTOSDemo_THUMB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: .\include;.\FreeRTOS\Include;.\application
  asm include: .\FreeRTOS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
